# Repository Nyokiyasu/MotorDriver

File README.md:

# MotorDriver
Motor Driver for RCsemi in TokyoNCT

## KiCad design MDcir_v0.2.1/MD_v0.2.1.kicad_pcb

Parts:
BT1: Battery; XT_M
C1, C2, C3, C4, C5, C11, C13, C15: 0.1u; C_0805_HandSoldering
C6: 4.7u; CP_Radial_D5.0mm_P2.00mm
C7: 0.47u; C_0402
C8: 4.7u; C_0805_HandSoldering
C9, C10: 0.22u; C_1206_HandSoldering
C12: 470u; CP_Radial_D8.0mm_P3.50mm
C14: 1000p; C_0603_HandSoldering
C16: 47u; C_1210_HandSoldering
D1: REVERSE; LED_0603
D2: FORWARD; LED_0603
D3: POWER; LED_0603
D4: FF2; LED_0603
D5: FF1; LED_0603
D6: D_Schottky; TUM-D2
D7: Low-Cost; TUM-D2
IC1: ADUM1310; SO-16-W
IC2: A3941; SOP65P640X120-29N
IC3: ACS715; SOIC-8-N
J1, J2: RJ45; 7810-8P8C
P1: XA_5Pin
P2: ST-LINK; Socket_Strip_Straight_1x06_Pitch2.54mm
P3, P5: SEL_5V; solder_pad
P4: MOTOR; XT_F
Q1, Q2, Q3, Q4: TK100E06N1; TO-220_Neutral123_Vertical
R1, R13, R14, R16, R17, R18, R19, R20: 10k; R_0603_HandSoldering
R2, R3, R4, R6, R7, R15: 1k; R_0603_HandSoldering
R5: 1.5k; R_0603_HandSoldering
R8: R; R_0603_HandSoldering
R9, R10, R11, R12: 10; R_0603_HandSoldering
SW1: SW_ROTARY; RotarySW
U1: MCP2551; SO-8
U2: STM32F042; LQFP-32_7x7mm_Pitch0.8mm
U3: 7805; TO-252-2Lead
U4: 033EZ1H; PQ033EZ1HZ

Connections:
+3V3: C1.1, C4.1, C15.2, C16.2, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, U1.3 (VDD), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDDIO2), U4.3 (Vout)
+5V: C15.1, IC1.1 (VDD1), J1.3, J1.4, J2.3, J2.4, U4.1 (Vin), U4.2 (ON/OFF)
+5VL: C6.1, D6.2 (A), P3.2, U3.3
+12V: J1.1, J1.2, J2.1, J2.2, P1.1
+24V: BT1.1, C5.1, C11.1, C12.1, D6.1 (K), D7.2 (A), IC2.1 (VDRAIN), Q1.2 (D), Q3.2 (D), U3.1
/ADUM_VDD2: C2.1, IC1.16 (VDD2), P3.1, P5.1
/CAN_RXD: U1.4 (RXD), U2.21 (PA11/CAN_RX/USART1_CTS/TIM1_CH4/TSC_G4_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)
/CAN_TXD: U1.1 (TXD), U2.22 (PA12/CAN_TX/USART1_RTS/TIM1_ETR/TSC_G4_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)
/Current: IC3.7 (VIOUT), U2.6 (PA0/USART2_CTS/TIM2_CH1_ETR/TSC_G1_IO1/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)
/ENC0_A: P1.3, R13.2, U2.13 (PA7/SPI1_MOSI/I2S1_SD/TIM3_CH2/TIM14_CH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)
/ENC0_B: P1.4, R14.2, U2.12 (PA6/SPI1_MISO/I2S1_MCK/TIM3_CH1/TIM1_BK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)
/ENC0_Z: P1.5, R20.2, U2.11 (PA5/SPI1_SCK/I2S1_CK/CEC/TIM2_CH1_ETR/T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)
/NRST: P2.5, U2.4 (NRST)
/SWCLK: P2.2, U2.24 (PA14/USART2_TX/SWCLK)
/SWDIO: P2.4, U2.23 (PA13/IR_OUT/SWDIO/USB_NOE)
/SWO: P2.6, U2.26 (PB3/SPI1_SCK/I2C1_CK/TIM2_CH2/TSC_G5_IO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)
/V5: C3.1, IC2.20 (V5), IC2.21 (SR), P5.2, R5.1, R6.1, R7.1
DIR[0]: D2.2 (A), U2.14 (PB0/TIM3_CH3/TIM1_CH2N/TSC_G3_IO2/EVENT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)
DIR[1]: D1.2 (A), U2.15 (PB1/TIM3_CH4/TIM14_CH1/TIM1_CH3N/TSC_G3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)
GND: C1.2, C4.2, C13.2, C14.2, C16.1, D3.1 (K), IC1.2 (GND1), IC1.7 (DISABLE), IC1.8 (GND1), IC3.5 (GND), J1.5, J1.6, J1.9 (SHIELD), J2.5, J2.6, J2.9 (SHIELD), P1.2, P2.3, R1.2, SW1.4 (GND), U1.2 (VSS), U2.16 (VSS), U2.32 (VSS), U4.5 (GND)
GNDD: BT1.2, C2.2, C3.2, C5.2, C6.2, C8.1, C11.2, C12.2, D4.1 (K), D5.1 (K), IC1.9 (GND2), IC1.10 (CTRL), IC1.15 (GND2), IC2.17 (GND), IC2.18 (GND), IC2.29 (GND), IC3.3 (IP-), IC3.4 (IP-), R4.2, R8.2, U3.2
unnamed: C7.1, IC2.15 (CP2)
unnamed: C7.2, IC2.16 (CP1)
unnamed: C8.2, IC2.7 (VREG), IC2.8 (VREG)
unnamed: C9.1, IC2.9 (CA)
unnamed: C9.2, IC2.11 (SA), P4.2, Q1.3 (S), Q2.2 (D)
unnamed: C10.1, IC2.6 (CB)
unnamed: C10.2, IC2.4 (SB), P4.1, Q3.3 (S), Q4.2 (D)
unnamed: C13.1, IC3.8 (VCC)
unnamed: C14.1, IC3.6 (FILTER)
unnamed: D1.1 (K), R2.1
unnamed: D2.1 (K), R3.1
unnamed: D3.2 (A), R15.2
unnamed: D4.2 (A), IC2.26 (FF2), R6.2
unnamed: D5.2 (A), IC2.25 (FF1), R7.2
unnamed: D7.1 (K), IC2.13 (VBB), IC2.14 (VBB)
unnamed: IC1.12 (VOC), IC2.23 (PWMH)
unnamed: IC1.13 (VOB), IC2.22 (PWML)
unnamed: IC1.14 (VOA), IC2.19 (PHASE)
unnamed: IC2.2 (LSS), IC3.1 (IP+), IC3.2 (IP+), Q2.3 (S), Q4.3 (S)
unnamed: IC2.3 (GLB), R12.2
unnamed: IC2.5 (GHB), R11.2
unnamed: IC2.10 (GHA), R9.1
unnamed: IC2.12 (GLA), R10.1
unnamed: IC2.27 (RDEAD), R8.1
unnamed: IC2.28 (VDSTH), R4.1, R5.2
unnamed: J1.7, J2.7, U1.7 (CANH)
unnamed: J1.8, J2.8, U1.6 (CANL)
unnamed: Q1.1 (G), R9.2
unnamed: Q2.1 (G), R10.2
unnamed: Q3.1 (G), R11.1
unnamed: Q4.1 (G), R12.1
unnamed: R1.1, U1.8 (RS)
unnamed: R16.2, SW1.1 (R1), U2.27 (PB4/SPI1_MISO/I2S1_MCK/TIM17_BKIN/TIM3_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)
unnamed: R17.2, SW1.2 (R2), U2.28 (PB5/SPI1_MOSI/I2S1_SD/I2C1_SMBA/TIM16_B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)
unnamed: R18.2, SW1.3 (R4), U2.29 (PB6/I2C1_SCL/USART1_TX/TIM16_CH1N/TSC_G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)
unnamed: R19.2, SW1.5 (R3), U2.30 (PB7/I2C1_SDA/USART1_RX/TIM17_CH1N/TSC_G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)
PHASE: IC1.3 (VIA), U2.9 (PA3/USART2_RX/TIM2_CH4/TSC_G1_IO4/ADC_I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)
PWM: R2.2, R3.2, U2.10 (PA4/SPI1_NSS/I2S1_WS/TIM14_CH1/TSC_G2_I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)
PWM_H: IC1.5 (VIC), U2.7 (PA1/USART2_RTS/TIM2_CH2/TSC_G1_IO2/EVEN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)
PWM_L: IC1.4 (VIB), U2.8 (PA2/USART2_TX/TIM2_CH3/TSC_G1_IO3/ADC_I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)

Notes on the sheet:
Please select voltage source of 5V.
For write to STM.
Power
For CAN

Board: 2 copper layers, 72.0 x 47.0 mm, 63 parts (27 on the bottom side), 61 nets.

## Commit log

2017-05-22 フィードバックの種類を追加
2017-05-23 基板のみのバージョン
2017-05-23 バージョン設定の変更
2017-05-23 プログラム書き始め
2017-05-23 未実装部分の明確化
2017-05-23 -プログラムのバージョン管理追加
2017-05-23 将来やりたいことの追加
2017-05-23 LED動作用プログラムの復元
2017-05-23 基板大きさ変更によりバージョン移行
2017-05-23 設計完了/発注済み
2017-05-24 test commit
2017-05-24 timerのセッティングを記述
2017-05-29 古い部品のレスキュー
2017-05-30 A3941&ディジタルアイソレータテスト
2017-05-31 Alternate functionの記述ちょっとした
2017-06-03 タイマの記述をしたけど動くかわかんない
2017-06-03 動かなかったから修正したけど動かない
2017-06-03 20kHz,Duty50でモーター回った
2017-06-04 CAN Addressの規則を決めてみた
2017-06-04 CANの関数追加
2017-06-04 従来のモータードライブ関数の追加
2017-06-06 debugできるようになった
2017-06-14 PWM Drive の内容を書き直した
2017-06-29 初期化関数を作成
2017-06-29 電流センサ用ADCの初期化を追加
2017-07-08 --allow-empty-message
2017-07-18 変更点なし
2017-09-24 5D実験用に使うため開発再開
2017-09-24 プログラムの読みやすさ向上とADC用の関数を追加
2018-03-05 研究室からの撤退
